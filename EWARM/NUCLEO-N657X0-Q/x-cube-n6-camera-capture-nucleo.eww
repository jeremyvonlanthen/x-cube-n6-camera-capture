<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\x-cube-n6-camera-capture-nucleo.ewp</path>
    </project>
    <batchBuild />
</workspace>